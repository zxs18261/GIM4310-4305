# Keil uVision project GIM4310（V0.0）.uvprojx, settings and files
target GIM4310（V0.0） (6240000::V6.24::ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GIM4310（V0_0） +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Application/config;../Application/bsp;../Application/control;../Application/app
  memory RVCT4: ROM 0x8000000 size 0x1f800
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c fdcan.c opamp.c spi.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Application/bsp
    ../Application/bsp/: bsp_adc.c bsp_can.c bsp_clock.c bsp_encoder.c bsp_flash.c bsp_pwm.c bsp_uart.c bsp_ws2812.c
  group Application/control
    ../Application/control/: calibration.c filter.c foc.c foc_math.c motor_ctrl.c pid.c protection.c
  group Application/app
    ../Application/app/: app_can_protocol.c app_led.c app_main.c app_monitor.c app_params.c app_shell.c
software components: CMSIS:CORE 4.3.0
